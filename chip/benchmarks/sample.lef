VERSION 5.8 ;

MACRO M1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 10 BY 10 ;
END M1

MACRO M2
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 10 BY 10 ;
END M2

END LIBRARY
